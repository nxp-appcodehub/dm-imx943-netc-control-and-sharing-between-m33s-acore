# IAR project netc_txrx_transfer_cm7_core1.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMX94398_M7_1 NXP MIMX94398_M7_1
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; PRINTF_ADVANCED_ENABLE=1; SDK_NETC_USED=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMX94398AVKM_cm7_core1; FSL_SDK_DISABLE_DRIVER_CLOCK_CONTROL=1; SDK_I2C_BASED_COMPONENT_USED=1; CODEC_MULTI_ADAPTERS=1; CODEC_WM8962_ENABLE; MCUX_ENABLE_PCA9544; MCUX_ENABLE_PCA9548
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe161
  ICCARM.IExtraOptions: --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../../../../../examples/_boards/imx943evk/sm; ../../../../../../../devices/MIMX94398/drivers/cm7_core1; ../../../../../../../devices/MIMX94398/drivers; ../../../../../../../CMSIS/Core/Include; ../../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../../devices/MIMX94398; ../../../../../../../devices/MIMX94398/periph; ../../../../../../../devices/MIMX94398/utilities/debug_console_lite; ../../../../../../../devices/MIMX94398/utilities/str; ../../../../../../../components/codec/i2c; ../../../../../../../components/codec; ../../../../../../../components/codec/port; ../../../../../../../components/codec/port/wm8962; ../../../../../../../components/codec/wm8962; ../../../../../../../components/i2c; ../../../../../../../components/i2c/muxes; ../../../../../../../components/reset1; ../../../../../../../components/reset1/porting/platform/imx943; ../../../../../../../components/uart; ../../../../../../../components/clock; ../../../../../../../components/clock/porting/platform/imx943; ../../../../../../../components/pinctrl; ../../../../../../../components/pinctrl/porting/platform/imx943; ../../../../../../../components/ele_base_api; ../../../../../../../components/power; ../../../../../../../components/power/porting/platform/imx943; ../../../../../../../components/expander/pca6416a; ../../../../../../../components/expander/pcal6408; ../../../../../../../components/phy; ../../../../../../../components/phy/device/phyrtl8211f; ../../../../../../../components/phy/device/phydp8384x; ../../../../../../../components/sm/clock; ../../../../../../../components/sm/pinctrl; ../../../../../../../components/sm/power; ../../../../../../../components/sm/reset; ../../../../../../../components/sm/porting/platform/imx943/cm7_core1; ../../../../../../../components/imx_sm_crc; ../../../../../../../components/scmi; ../../../../../../../components/smt
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; CPU_MIMX94398AVKM_cm7_core1
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: netc_txrx_transfer.bin
  ILINK.IlinkOutputFile: netc_txrx_transfer_cm7_core1.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000
  ILINK.IlinkIcfFile: MIMX94398_cm7_core1_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; PRINTF_ADVANCED_ENABLE=1; SDK_NETC_USED=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMX94398AVKM_cm7_core1; FSL_SDK_DISABLE_DRIVER_CLOCK_CONTROL=1; SDK_I2C_BASED_COMPONENT_USED=1; CODEC_MULTI_ADAPTERS=1; CODEC_WM8962_ENABLE; MCUX_ENABLE_PCA9544; MCUX_ENABLE_PCA9548
  ICCARM.CCOptLevel: 3
  group source
    ../: netc_txrx_transfer.c mcux_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h hardware_init.c app.h
  group examples/_boards/imx943evk/sm
    ../../../../../../../examples/_boards/imx943evk/sm/: hal_config.h
  group drivers
    ../../../../../../../devices/MIMX94398/drivers/cm7_core1/: fsl_irqsteer_soc.h fsl_irqsteer_soc.c
    ../../../../../../../devices/MIMX94398/drivers/: fsl_elec_spec.h fsl_reset.c fsl_reset.h fsl_trdc_soc.h fsl_clock.c fsl_clock.h fsl_iomuxc.h fsl_supply.h fsl_cpu.c fsl_cpu.h fsl_memory.h fsl_power.h fsl_power.c fsl_ccm.c fsl_ccm.h fsl_src.c fsl_src.h fsl_fro.c fsl_fro.h fsl_cache.c fsl_cache.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_fract_pll.h fsl_fract_pll.c fsl_irqsteer.h fsl_irqsteer.c fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.h fsl_lpuart.c fsl_msgintr.h fsl_msgintr.c fsl_mu.h fsl_mu.c fsl_rgpio.h fsl_rgpio.c fsl_s3mu.c fsl_s3mu.h fsl_sramctl.c fsl_sramctl.h
  group drivers/netc
    ../../../../../../../devices/MIMX94398/drivers/: fsl_netc_soc.c fsl_netc_soc.h fsl_netc.h fsl_netc_ierb.h fsl_netc_ierb.c fsl_netc_timer.h fsl_netc_timer.c fsl_netc_mdio.h fsl_netc_mdio.c fsl_netc_endpoint.h fsl_netc_endpoint.c fsl_netc_switch.h fsl_netc_tag.h fsl_netc_switch.c fsl_netc_phy_wrapper.h fsl_netc_phy_wrapper.c
  group drivers/netc/netc_hw
    ../../../../../../../devices/MIMX94398/drivers/netc_hw/: fsl_netc_hw.h fsl_netc_hw.c fsl_netc_hw_port.c fsl_netc_hw_port.h fsl_netc_hw_si.c fsl_netc_hw_si.h fsl_netc_hw_enetc.c fsl_netc_hw_enetc.h
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm7.h
  group CMSIS/m-profile
    ../../../../../../../CMSIS/Core/Include/m-profile/: cmsis_iccarm_m.h armv7m_cachel1.h armv7m_mpu.h
  group device
    ../../../../../../../devices/MIMX94398/: fsl_device_registers.h MIMX94398_cm7_core1.h MIMX94398_cm7_core1_COMMON.h MIMX94398_cm7_core1_features.h system_MIMX94398_cm7_core1.c system_MIMX94398_cm7_core1.h
  group device/periph
    ../../../../../../../devices/MIMX94398/periph/: PERI_ADC.h PERI_ANALOG_AGDET.h PERI_ANALOG_CMU.h PERI_ANALOG_PMRO.h PERI_ANALOG_SFA.h PERI_ANALOG_TCU.h PERI_ANALOG_VDET.h PERI_AOI.h PERI_AON_CMU.h PERI_AON_CRC.h PERI_AON_CSTCU.h PERI_AON_EIM.h PERI_AON_ERM.h PERI_AON_FCCU.h PERI_AON_INTM.h PERI_AON_LSTCU.h PERI_AON_MCM.h PERI_AON_SYSPM.h PERI_AON_TCU.h PERI_AON_TRDC_MGR.h PERI_ARDB.h PERI_ATU_USB2.h PERI_AXBS.h PERI_BBNSM.h PERI_BBSM_BLK_CTRL_BBSMMIX.h PERI_BBSM_TCU.h PERI_BISS.h PERI_BLK_CTRL_NETCMIX.h PERI_BLK_CTRL_NS_AONMIX.h PERI_BLK_CTRL_S_AONMIX.h PERI_BLK_CTRL_WAKEUPMIX.h PERI_CACHE_ECC_MCM.h PERI_CAMERA_ATU.h PERI_CAMIX_BLK_CTRL.h PERI_CAN.h PERI_CCM.h PERI_CCMSRCGPC_TCU.h PERI_CORTEXA_TCU.h PERI_DCIF.h PERI_DDR_BLK_CTRL_DDRMIX.h PERI_DDR_CMU.h PERI_DDR_DDRC.h PERI_DDR_LSTCU.h PERI_DDR_TCU.h PERI_DISPLAY_BLK_CTRL_DISPLAYMIX.h PERI_DISPLAY_BLK_CTRL_LVDS.h PERI_DISPLAY_TCU.h PERI_DISPLAY_TRDC_MGR.h PERI_DMA.h PERI_DMA5.h PERI_DWC_USB3.h PERI_ECAT.h PERI_ENDAT2P2.h PERI_ENDAT3.h PERI_ENETC_COMMON.h PERI_ENETC_GLOBAL.h PERI_ENETC_PCI_TYPE0.h PERI_ENETC_PF_EMDIO.h PERI_ENETC_PF_TMR.h PERI_ENETC_PORT.h PERI_ENETC_SI.h PERI_ENETC_VF_PCI_TYPE0.h PERI_ENET_PHY_CTRL_EX.h PERI_ENET_PHY_MAC_ADAPTER.h PERI_EQDC.h PERI_EWM.h PERI_FLEXIO.h PERI_FRO.h PERI_GLITCHFILTER.h PERI_GPC_CPU_CTRL.h PERI_GPC_GLOBAL.h PERI_GPT.h PERI_HIPERFACE.h PERI_HSIO_BLK_CTRL_HSIOMIX.h PERI_HSIO_TCU.h PERI_HSIO_TRDC_MGR.h PERI_I2S.h PERI_I3C.h PERI_IEPRC_IERB.h PERI_IEPRC_PCI.h PERI_IEPRC_PRB.h PERI_IOMUXC.h PERI_IOMUXC_GPR.h PERI_IRQSTEER.h PERI_IRQSTEERA55.h PERI_LPI2C.h PERI_LPIT.h PERI_LPSPI.h PERI_LPTMR.h PERI_LPUART.h PERI_M7_A7_APB_MCM.h PERI_M7_A7_PPB_MCM.h PERI_M7_CMU.h PERI_M7_EIM.h PERI_M7_ERM.h PERI_M7_LSTCU.h PERI_M7_TCU.h PERI_MSGINTR.h PERI_MU.h PERI_M_E_3_WR_I_MAIN_TRANSTATFILT.h PERI_M_E_9_RD_I_MAIN_TRANSACTIONSTATFILTER.h PERI_NECTMIX_CM33_AIPS.h PERI_NETC_CMU.h PERI_NETC_EIM.h PERI_NETC_ENETC.h PERI_NETC_ERM.h PERI_NETC_ETH_LINK.h PERI_NETC_IERB.h PERI_NETC_LSTCU.h PERI_NETC_MAX_CORE.h PERI_NETC_OCSRAM_MCM.h PERI_NETC_PORT.h PERI_NETC_PRIV.h PERI_NETC_PSEUDO_LINK.h PERI_NETC_SW.h PERI_NETC_SW_ENETC.h PERI_NETC_TCU.h PERI_NETC_TCU_CM33.h PERI_NETC_TMR_BASE.h PERI_NETC_TRDC_MGR.h PERI_NETC_TRDC_MGR_CM33.h PERI_NEUTRON.h PERI_NEUTRONS.h PERI_NOC_ALWAYS_ON_MAIN_RESFAULTCNTR.h PERI_NOC_BLK_CTRL_NOCMIX.h PERI_NOC_CMU.h PERI_NOC_EIM.h PERI_NOC_GICA.h PERI_NOC_GICD.h PERI_NOC_GICDA.h PERI_NOC_GICP.h PERI_NOC_GICRLPI0.h PERI_NOC_GICRLPI1.h PERI_NOC_GICRLPI2.h PERI_NOC_GICRLPI3.h PERI_NOC_GICRSGI0.h PERI_NOC_GICRSGI2.h PERI_NOC_GICRSGI3.h PERI_NOC_GICRSGIL.h PERI_NOC_GICT.h PERI_NOC_GITS0.h PERI_NOC_GITS0TRANSLATER.h PERI_NOC_I_LCDIF_RD_I_MAIN_QOSG.h PERI_NOC_I_LCDIF_RD_I_MAIN_TRANSTATFLTR.h PERI_NOC_I_PXP_RD_I_MAIN_QOSG.h PERI_NOC_I_PXP_RD_I_MAIN_TRANSTATFLTR.h PERI_NOC_I_PXP_WR_I_MAIN_QOSG.h PERI_NOC_I_PXP_WR_I_MAIN_TRANSTATFLTR.h PERI_NOC_LSTCU.h PERI_NOC_M_E_0_RD_I_MAIN_TRANSTATFILT.h PERI_NOC_M_E_0_RD_I_M_QOSGEN.h PERI_NOC_M_E_0_WR_I_MAIN_QOSGEN.h PERI_NOC_M_E_0_WR_I_MAIN_TRANSTATFILT.h PERI_NOC_M_E_1A_RD_I_MAIN_QOSGEN.h PERI_NOC_M_E_1A_WR_I_MAIN_QOSGEN.h PERI_NOC_M_E_1B_RD_I_MAIN_QOSGEN.h PERI_NOC_M_E_1B_WR_I_MAIN_QOSGEN.h PERI_NOC_M_E_3_RD_I_MAIN_QOSGEN.h PERI_NOC_M_E_3_RD_I_MAIN_TRANSTATFILT.h PERI_NOC_M_E_3_WR_I_MAIN_QOSGEN.h PERI_NOC_M_E_6_RD_I_MAIN_QOSGEN.h PERI_NOC_M_E_6_RD_I_MAIN_TRANSTATFILT.h PERI_NOC_M_E_6_WR_I_MAIN_QOSGEN.h PERI_NOC_M_E_6_WR_I_MAIN_TRANSTATFILT.h PERI_NOC_M_E_7_RD_I_MAIN_QOSGEN.h PERI_NOC_M_E_7_RD_I_MAIN_TRANSTATFILT.h PERI_NOC_M_E_7_WR_I_MAIN_QOSGEN.h PERI_NOC_M_E_7_WR_I_MAIN_TRANSTATFILT.h PERI_NOC_M_E_9_RD_I_MAIN_QOSGEN.h PERI_NOC_M_E_9_WR_I_MAIN_QOSGEN.h PERI_NOC_M_E_9_WR_I_MAIN_TRANSTATFILT.h PERI_NOC_PROBE_LCDIF_RD_MAIN_PROBE.h PERI_NOC_PROBE_LCDIF_RD_MAIN_TRSTPROF.h PERI_NOC_PROBE_M_E_0_MAIN_PROBE.h PERI_NOC_PROBE_M_E_0_MAIN_TRANSTATPROF.h PERI_NOC_PROBE_M_E_3_MAIN_PROBE.h PERI_NOC_PROBE_M_E_3_MAIN_TRANSTATPROF.h PERI_NOC_PROBE_M_E_6_MAIN_PROBE.h PERI_NOC_PROBE_M_E_6_MAIN_TRANSTATPROF.h PERI_NOC_PROBE_M_E_7_MAIN_PROBE.h PERI_NOC_PROBE_M_E_7_MAIN_TRANSTATPROF.h PERI_NOC_PROBE_M_E_9_MAIN_PROBE.h PERI_NOC_PROBE_M_E_9_MAIN_TRANSTATPROF.h PERI_NOC_PROBE_PXP_RD_MAIN_PROBE.h PERI_NOC_PROBE_PXP_RD_MAIN_TRSTPROF.h PERI_NOC_PROBE_PXP_WR_MAIN_PROBE.h PERI_NOC_PROBE_PXP_WR_MAIN_TRSTPROF.h PERI_NOC_TCU.h PERI_NOC_TRDC_MGR.h PERI_NPU_EIM.h PERI_NPU_ERM.h PERI_NPU_LSTCU.h PERI_NPU_TCU.h PERI_OSC24M.h PERI_PCIE_DMA_IATU.h PERI_PCIE_EP.h PERI_PCIE_RC.h PERI_PCIE_SHADOW_EP.h PERI_PDM.h PERI_PLL.h PERI_PWM.h PERI_PXP.h PERI_RGPIO.h PERI_S3MU.h PERI_SEMA42.h PERI_SERDES_SS.h PERI_SINC.h PERI_SRAMCTL.h PERI_SRC_GEN.h PERI_SRC_MEM.h PERI_SRC_XSPR.h PERI_SW_GLOBAL.h PERI_SW_PORT.h PERI_SW_PSEUDO_MAC_PORT.h PERI_SYS_CTR_COMPARE.h PERI_SYS_CTR_CONTROL.h PERI_SYS_CTR_READ.h PERI_TCM_ECC_MCM.h PERI_TMPSNS.h PERI_TMR.h PERI_TMR_GLOBAL.h PERI_TMR_PCI_HDR_TYPE0.h PERI_TPM.h PERI_TRDC_MGR_WKUP1.h PERI_TRDC_MGR_WKUP2.h PERI_TSTMR.h PERI_USB.h PERI_USB3_GLUE.h PERI_USB3_PHY_TCA.h PERI_USBNC.h PERI_WAKEUP_ATU.h PERI_WAKEUP_CMU.h PERI_WAKEUP_DMA_CRC.h PERI_WAKEUP_EIM.h PERI_WAKEUP_ERM.h PERI_WAKEUP_GPT.h PERI_WAKEUP_SAI.h PERI_WAKEUP_TCW.h PERI_WAKEUP_TRDC_MGR_MEGA.h PERI_WAKEUP_USDHC.h PERI_WAKEUP_XSPI_RESPONDER.h PERI_WDOG.h PERI_XBAR1.h PERI_XBAR2.h PERI_XBAR3.h PERI_XCACHE.h PERI_XSPI.h
  group startup/iar
    ../../../../../../../devices/MIMX94398/iar/: startup_MIMX94398_cm7_core1.s
  group utilities
    ../../../../../../../devices/MIMX94398/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
  group utilities/str
    ../../../../../../../devices/MIMX94398/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../../../devices/MIMX94398/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group codec
    ../../../../../../../components/codec/i2c/: fsl_codec_i2c.h fsl_codec_i2c.c
    ../../../../../../../components/codec/: fsl_codec_common.h fsl_codec_common.c
    ../../../../../../../components/codec/wm8962/: fsl_wm8962.h fsl_wm8962.c
  group codec/port
    ../../../../../../../components/codec/port/: fsl_codec_adapter.c fsl_codec_adapter.h
  group codec/port/wm8962
    ../../../../../../../components/codec/port/wm8962/: fsl_codec_wm8962_adapter.h fsl_codec_wm8962_adapter.c
  group component/i2c
    ../../../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_lpi2c.c
  group component/i2c/muxes
    ../../../../../../../components/i2c/muxes/: fsl_pca954x.h fsl_pca954x.c
  group component/reset1
    ../../../../../../../components/reset1/: hal_reset.h hal_reset.c
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/clock
    ../../../../../../../components/clock/: hal_clock.h hal_clock.c
  group component/pinctrl
    ../../../../../../../components/pinctrl/: hal_pinctrl.h hal_pinctrl.c
  group component/ele_base_api
    ../../../../../../../components/ele_base_api/: fsl_ele_base_api.c fsl_ele_base_api.h
  group component/power
    ../../../../../../../components/power/: hal_power.h hal_power.c
  group component/expander/pca6416a
    ../../../../../../../components/expander/pca6416a/: fsl_pca6416a.c fsl_pca6416a.h
  group component/expander/pcal6408
    ../../../../../../../components/expander/pcal6408/: fsl_pcal6408.c fsl_pcal6408.h
  group component/phy
    ../../../../../../../components/phy/: fsl_phy.h
    ../../../../../../../components/phy/device/phyrtl8211f/: fsl_phyrtl8211f.c fsl_phyrtl8211f.h
    ../../../../../../../components/phy/device/phydp8384x/: fsl_phydp8384x.c fsl_phydp8384x.h
  group components/reset1/porting/platform/imx943
    ../../../../../../../components/reset1/porting/platform/imx943/: hal_reset_platform.h hal_reset_platform.c
  group components/clock/porting/platform/imx943
    ../../../../../../../components/clock/porting/platform/imx943/: hal_clock_platform.h hal_clock_platform.c
  group components/pinctrl/porting/platform/imx943
    ../../../../../../../components/pinctrl/porting/platform/imx943/: hal_pinctrl_platform.h
  group components/power/porting/platform/imx943
    ../../../../../../../components/power/porting/platform/imx943/: hal_power_platform.h
  group components/sm/clock
    ../../../../../../../components/sm/clock/: sm_clock.h sm_clock.c
  group components/sm/pinctrl
    ../../../../../../../components/sm/pinctrl/: sm_pinctrl.h sm_pinctrl.c
  group components/sm/power
    ../../../../../../../components/sm/power/: sm_power.h sm_power.c
  group components/sm/reset
    ../../../../../../../components/sm/reset/: sm_reset.h sm_reset.c
  group components/sm/porting/platform/imx943/cm7_core1
    ../../../../../../../components/sm/porting/platform/imx943/cm7_core1/: sm_platform.h sm_platform.c
  group components/imx_sm_crc
    ../../../../../../../components/imx_sm_crc/: crc.h crc.c
  group components/scmi
    ../../../../../../../components/scmi/: scmi_common.h scmi.c scmi.h scmi_clock.c scmi_clock.h scmi_base.c scmi_base.h scmi_bbm.c scmi_bbm.h scmi_cpu.c scmi_cpu.h scmi_fusa.c scmi_fusa.h scmi_internal.h scmi_lmm.c scmi_lmm.h scmi_misc.c scmi_misc.h scmi_perf.c scmi_perf.h scmi_pinctrl.c scmi_pinctrl.h scmi_power.c scmi_power.h scmi_reset.c scmi_reset.h scmi_sensor.c scmi_sensor.h scmi_sys.c scmi_sys.h scmi_voltage.c scmi_voltage.h
  group components/smt
    ../../../../../../../components/smt/: smt.h smt.c
  group doc
    ../: readme.md
