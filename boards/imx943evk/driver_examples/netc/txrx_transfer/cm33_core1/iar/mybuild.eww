<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\netc_txrx_transfer_cm33_core1.ewp</path>
    </project>
    <batchBuild />
</workspace>
