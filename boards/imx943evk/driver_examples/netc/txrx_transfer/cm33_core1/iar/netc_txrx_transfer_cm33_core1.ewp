# IAR project netc_txrx_transfer_cm33_core1.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMX94398_M33_1 NXP MIMX94398_M33_1
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; PRINTF_ADVANCED_ENABLE=1; SERIAL_PORT_TYPE_UART=1; SDK_NETC_USED=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMX94398AVKM_cm33_core1; FSL_SDK_DISABLE_DRIVER_CLOCK_CONTROL=1; SDK_I2C_BASED_COMPONENT_USED=1; CODEC_MULTI_ADAPTERS=1; CODEC_WM8962_ENABLE; MCUX_ENABLE_PCA9544; MCUX_ENABLE_PCA9548
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe161
  ICCARM.IExtraOptions: --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../../../../../examples/_boards/imx943evk; ../../../../../../../examples/_boards/imx943evk/sm; ../../../../../../../components/srtm/channels; ../../../../../../../components/srtm/services; ../../../../../../../devices/MIMX94398/drivers/cm33_core1; ../../../../../../../devices/MIMX94398/drivers; ../../../../../../../CMSIS/Core/Include; ../../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../../devices/MIMX94398; ../../../../../../../devices/MIMX94398/periph; ../../../../../../../devices/MIMX94398/drivers/cm33; ../../../../../../../devices/MIMX94398/utilities/debug_console_lite; ../../../../../../../devices/MIMX94398/utilities/str; ../../../../../../../devices/MIMX94398/utilities/shell; ../../../../../../../middleware/multicore/rpmsg-lite/lib/include/platform/imx943_m33; ../../../../../../../middleware/multicore/rpmsg-lite/lib/include/environment/freertos; ../../../../../../../middleware/multicore/rpmsg-lite/lib/include; ../../../../../../../components/codec/i2c; ../../../../../../../components/codec; ../../../../../../../components/codec/port; ../../../../../../../components/codec/port/wm8962; ../../../../../../../components/codec/wm8962; ../../../../../../../components/crc; ../../../../../../../components/i2c; ../../../../../../../components/i2c/muxes; ../../../../../../../components/reset1; ../../../../../../../components/reset1/porting/platform/imx943; ../../../../../../../components/uart; ../../../../../../../components/clock; ../../../../../../../components/clock/porting/platform/imx943; ../../../../../../../components/pinctrl; ../../../../../../../components/pinctrl/porting/platform/imx943; ../../../../../../../components/ele_base_api; ../../../../../../../components/power; ../../../../../../../components/power/porting/platform/imx943; ../../../../../../../components/expander/pca6416a; ../../../../../../../components/expander/pcal6408; ../../../../../../../components/phy; ../../../../../../../components/phy/device/phyrtl8211f; ../../../../../../../components/phy/device/phydp8384x; ../../../../../../../components/sm/clock; ../../../../../../../components/sm/pinctrl; ../../../../../../../components/sm/power; ../../../../../../../components/sm/reset; ../../../../../../../components/sm/porting/platform/imx943/cm33_core1; ../../../../../../../components/imx_sm_crc; ../../../../../../../components/scmi; ../../../../../../../components/smt; ../../../../../../../components/lists; ../../../../../../../components/serial_manager; ../../../../../../../middleware/multicore/remoteproc; ../../../../../../../rtos/freertos/freertos-kernel/include; ../../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure; ../../../../../../../rtos/freertos/freertos-kernel/template; ../../../../../../../components/srtm/include; ../../../../../../../components/srtm/srtm; ../../../../../../../components/srtm/port; ../../../../../../../devices/MIMX94398/drivers/edma4
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; CPU_MIMX94398AVKM_cm33_core1
  AARM.AUserIncludes: ..; ../../../../../../../examples/_boards/imx943evk/sm; ../../../../../../../devices/MIMX94398/drivers/cm33_core1; ../../../../../../../devices/MIMX94398/drivers; ../../../../../../../CMSIS/Core/Include; ../../../../../../../CMSIS/Core/Include/m-profile; ../../../../../../../devices/MIMX94398; ../../../../../../../devices/MIMX94398/periph; ../../../../../../../devices/MIMX94398/drivers/cm33; ../../../../../../../devices/MIMX94398/utilities/debug_console_lite; ../../../../../../../devices/MIMX94398/utilities/str; ../../../../../../../devices/MIMX94398/utilities/shell; ../../../../../../../components/codec/i2c; ../../../../../../../components/codec; ../../../../../../../components/codec/port; ../../../../../../../components/codec/port/wm8962; ../../../../../../../components/codec/wm8962; ../../../../../../../components/crc; ../../../../../../../components/i2c; ../../../../../../../components/i2c/muxes; ../../../../../../../components/reset1; ../../../../../../../components/reset1/porting/platform/imx943; ../../../../../../../components/uart; ../../../../../../../components/clock; ../../../../../../../components/clock/porting/platform/imx943; ../../../../../../../components/pinctrl; ../../../../../../../components/pinctrl/porting/platform/imx943; ../../../../../../../components/ele_base_api; ../../../../../../../components/power; ../../../../../../../components/power/porting/platform/imx943; ../../../../../../../components/expander/pca6416a; ../../../../../../../components/expander/pcal6408; ../../../../../../../components/phy; ../../../../../../../components/phy/device/phyrtl8211f; ../../../../../../../components/phy/device/phydp8384x; ../../../../../../../components/sm/clock; ../../../../../../../components/sm/pinctrl; ../../../../../../../components/sm/power; ../../../../../../../components/sm/reset; ../../../../../../../components/sm/porting/platform/imx943/cm33_core1; ../../../../../../../components/imx_sm_crc; ../../../../../../../components/scmi; ../../../../../../../components/smt; ../../../../../../../components/lists; ../../../../../../../components/serial_manager; ../../../../../../../middleware/multicore/remoteproc; ../../../../../../../rtos/freertos/freertos-kernel/include; ../../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure; ../../../../../../../rtos/freertos/freertos-kernel/template
  OBJCOPY.OOCOutputFile: netc_txrx_transfer.bin
  ILINK.IlinkOutputFile: netc_txrx_transfer_cm33_core1.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000
  ILINK.IlinkIcfFile: MIMX94398_cm33_core1_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  General.CoreVariant: 58
  ICCARM.CCDefines: NDEBUG; PRINTF_ADVANCED_ENABLE=1; SERIAL_PORT_TYPE_UART=1; SDK_NETC_USED=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MIMX94398AVKM_cm33_core1; FSL_SDK_DISABLE_DRIVER_CLOCK_CONTROL=1; SDK_I2C_BASED_COMPONENT_USED=1; CODEC_MULTI_ADAPTERS=1; CODEC_WM8962_ENABLE; MCUX_ENABLE_PCA9544; MCUX_ENABLE_PCA9548
  ICCARM.CCOptLevel: 3
  group board
    ../: app.h board.c board.h clock_config.c clock_config.h hardware_init.c pin_mux.c pin_mux.h
  group CMSIS
    ../../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../../../CMSIS/Core/Include/m-profile/: armv8m_mpu.h cmsis_iccarm_m.h
  group codec
    ../../../../../../../components/codec/: fsl_codec_common.c fsl_codec_common.h
    ../../../../../../../components/codec/i2c/: fsl_codec_i2c.c fsl_codec_i2c.h
    ../../../../../../../components/codec/wm8962/: fsl_wm8962.c fsl_wm8962.h
  group codec/port
    ../../../../../../../components/codec/port/: fsl_codec_adapter.c fsl_codec_adapter.h
  group codec/port/wm8962
    ../../../../../../../components/codec/port/wm8962/: fsl_codec_wm8962_adapter.c fsl_codec_wm8962_adapter.h
  group component/clock
    ../../../../../../../components/clock/: hal_clock.c hal_clock.h
  group component/crc
    ../../../../../../../components/crc/: fsl_adapter_crc.h fsl_adapter_software_crc.c
  group component/ele_base_api
    ../../../../../../../components/ele_base_api/: fsl_ele_base_api.c fsl_ele_base_api.h
  group component/expander/pca6416a
    ../../../../../../../components/expander/pca6416a/: fsl_pca6416a.c fsl_pca6416a.h
  group component/expander/pcal6408
    ../../../../../../../components/expander/pcal6408/: fsl_pcal6408.c fsl_pcal6408.h
  group component/i2c
    ../../../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_lpi2c.c
  group component/i2c/muxes
    ../../../../../../../components/i2c/muxes/: fsl_pca954x.c fsl_pca954x.h
  group component/phy
    ../../../../../../../components/phy/: fsl_phy.h
    ../../../../../../../components/phy/device/phydp8384x/: fsl_phydp8384x.c fsl_phydp8384x.h
    ../../../../../../../components/phy/device/phyrtl8211f/: fsl_phyrtl8211f.c fsl_phyrtl8211f.h
  group component/pinctrl
    ../../../../../../../components/pinctrl/: hal_pinctrl.c hal_pinctrl.h
  group component/power
    ../../../../../../../components/power/: hal_power.c hal_power.h
  group component/reset1
    ../../../../../../../components/reset1/: hal_reset.c hal_reset.h
  group component/uart
    ../../../../../../../components/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group components/clock/porting/platform/imx943
    ../../../../../../../components/clock/porting/platform/imx943/: hal_clock_platform.c hal_clock_platform.h
  group components/imx_sm_crc
    ../../../../../../../components/imx_sm_crc/: crc.c crc.h
  group components/pinctrl/porting/platform/imx943
    ../../../../../../../components/pinctrl/porting/platform/imx943/: hal_pinctrl_platform.h
  group components/power/porting/platform/imx943
    ../../../../../../../components/power/porting/platform/imx943/: hal_power_platform.h
  group components/reset1/porting/platform/imx943
    ../../../../../../../components/reset1/porting/platform/imx943/: hal_reset_platform.c hal_reset_platform.h
  group components/scmi
    ../../../../../../../components/scmi/: scmi.c scmi.h scmi_base.c scmi_base.h scmi_bbm.c scmi_bbm.h scmi_clock.c scmi_clock.h scmi_common.h scmi_cpu.c scmi_cpu.h scmi_fusa.c scmi_fusa.h scmi_internal.h scmi_lmm.c scmi_lmm.h scmi_misc.c scmi_misc.h scmi_perf.c scmi_perf.h scmi_pinctrl.c scmi_pinctrl.h scmi_power.c scmi_power.h scmi_reset.c scmi_reset.h scmi_sensor.c scmi_sensor.h scmi_sys.c scmi_sys.h scmi_voltage.c scmi_voltage.h
  group components/sm/clock
    ../../../../../../../components/sm/clock/: sm_clock.c sm_clock.h
  group components/sm/pinctrl
    ../../../../../../../components/sm/pinctrl/: sm_pinctrl.c sm_pinctrl.h
  group components/sm/porting/platform/imx943/cm33_core1
    ../../../../../../../components/sm/porting/platform/imx943/cm33_core1/: sm_platform.c sm_platform.h
  group components/sm/power
    ../../../../../../../components/sm/power/: sm_power.c sm_power.h
  group components/sm/reset
    ../../../../../../../components/sm/reset/: sm_reset.c sm_reset.h
  group components/smt
    ../../../../../../../components/smt/: smt.c smt.h
  group components/lists
    ../../../../../../../components/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group components/serial_manager
    ../../../../../../../components/serial_manager/: fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_manager.h fsl_component_serial_port_uart.c fsl_component_serial_port_uart.h fsl_component_serial_port_swo.c fsl_component_serial_port_swo.h fsl_component_serial_port_virtual.c fsl_component_serial_port_virtual.h
  group device
    ../../../../../../../devices/MIMX94398/: fsl_device_registers.h MIMX94398_cm33_core1.h MIMX94398_cm33_core1_COMMON.h MIMX94398_cm33_core1_features.h system_MIMX94398_cm33_core1.c system_MIMX94398_cm33_core1.h
  group device/periph
    ../../../../../../../devices/MIMX94398/periph/: PERI_ADC.h PERI_ANALOG_AGDET.h PERI_ANALOG_CMU.h PERI_ANALOG_PMRO.h PERI_ANALOG_SFA.h PERI_ANALOG_TCU.h PERI_ANALOG_VDET.h PERI_AOI.h PERI_AON_CMU.h PERI_AON_CRC.h PERI_AON_CSTCU.h PERI_AON_EIM.h PERI_AON_ERM.h PERI_AON_FCCU.h PERI_AON_INTM.h PERI_AON_LSTCU.h PERI_AON_MCM.h PERI_AON_SYSPM.h PERI_AON_TCU.h PERI_AON_TRDC_MGR.h PERI_ARDB.h PERI_ATU_USB2.h PERI_AXBS.h PERI_BBNSM.h PERI_BBSM_BLK_CTRL_BBSMMIX.h PERI_BBSM_TCU.h PERI_BISS.h PERI_BLK_CTRL_NETCMIX.h PERI_BLK_CTRL_NS_AONMIX.h PERI_BLK_CTRL_S_AONMIX.h PERI_BLK_CTRL_WAKEUPMIX.h PERI_CACHE_ECC_MCM.h PERI_CAMERA_ATU.h PERI_CAMIX_BLK_CTRL.h PERI_CAN.h PERI_CCM.h PERI_CCMSRCGPC_TCU.h PERI_CORTEXA_TCU.h PERI_DCIF.h PERI_DDR_BLK_CTRL_DDRMIX.h PERI_DDR_CMU.h PERI_DDR_DDRC.h PERI_DDR_LSTCU.h PERI_DDR_TCU.h PERI_DISPLAY_BLK_CTRL_DISPLAYMIX.h PERI_DISPLAY_BLK_CTRL_LVDS.h PERI_DISPLAY_TCU.h PERI_DISPLAY_TRDC_MGR.h PERI_DMA.h PERI_DMA5.h PERI_DWC_USB3.h PERI_ECAT.h PERI_ENDAT2P2.h PERI_ENDAT3.h PERI_ENET_PHY_CTRL_EX.h PERI_ENET_PHY_MAC_ADAPTER.h PERI_ENETC_COMMON.h PERI_ENETC_GLOBAL.h PERI_ENETC_PCI_TYPE0.h PERI_ENETC_PF_EMDIO.h PERI_ENETC_PF_TMR.h PERI_ENETC_PORT.h PERI_ENETC_SI.h PERI_ENETC_VF_PCI_TYPE0.h PERI_EQDC.h PERI_EWM.h PERI_FLEXIO.h PERI_FRO.h PERI_GLITCHFILTER.h PERI_GPC_CPU_CTRL.h PERI_GPC_GLOBAL.h PERI_GPT.h PERI_HIPERFACE.h PERI_HSIO_BLK_CTRL_HSIOMIX.h PERI_HSIO_TCU.h PERI_HSIO_TRDC_MGR.h PERI_I2S.h PERI_I3C.h PERI_IEPRC_IERB.h PERI_IEPRC_PCI.h PERI_IEPRC_PRB.h PERI_IOMUXC.h PERI_IOMUXC_GPR.h PERI_IRQSTEER.h PERI_IRQSTEERA55.h PERI_LPI2C.h PERI_LPIT.h PERI_LPSPI.h PERI_LPTMR.h PERI_LPUART.h PERI_M7_A7_APB_MCM.h PERI_M7_A7_PPB_MCM.h PERI_M7_CMU.h PERI_M7_EIM.h PERI_M7_ERM.h PERI_M7_LSTCU.h PERI_M7_TCU.h PERI_M_E_3_WR_I_MAIN_TRANSTATFILT.h PERI_M_E_9_RD_I_MAIN_TRANSACTIONSTATFILTER.h PERI_MSGINTR.h PERI_MU.h PERI_NECTMIX_CM33_AIPS.h PERI_NETC_CMU.h PERI_NETC_EIM.h PERI_NETC_ENETC.h PERI_NETC_ERM.h PERI_NETC_ETH_LINK.h PERI_NETC_IERB.h PERI_NETC_LSTCU.h PERI_NETC_MAX_CORE.h PERI_NETC_OCSRAM_MCM.h PERI_NETC_PORT.h PERI_NETC_PRIV.h PERI_NETC_PSEUDO_LINK.h PERI_NETC_SW.h PERI_NETC_SW_ENETC.h PERI_NETC_TCU.h PERI_NETC_TCU_CM33.h PERI_NETC_TMR_BASE.h PERI_NETC_TRDC_MGR.h PERI_NETC_TRDC_MGR_CM33.h PERI_NEUTRON.h PERI_NEUTRONS.h PERI_NOC_ALWAYS_ON_MAIN_RESFAULTCNTR.h PERI_NOC_BLK_CTRL_NOCMIX.h PERI_NOC_CMU.h PERI_NOC_EIM.h PERI_NOC_GICA.h PERI_NOC_GICD.h PERI_NOC_GICDA.h PERI_NOC_GICP.h PERI_NOC_GICRLPI0.h PERI_NOC_GICRLPI1.h PERI_NOC_GICRLPI2.h PERI_NOC_GICRLPI3.h PERI_NOC_GICRSGI0.h PERI_NOC_GICRSGI2.h PERI_NOC_GICRSGI3.h PERI_NOC_GICRSGIL.h PERI_NOC_GICT.h PERI_NOC_GITS0.h PERI_NOC_GITS0TRANSLATER.h PERI_NOC_I_LCDIF_RD_I_MAIN_QOSG.h PERI_NOC_I_LCDIF_RD_I_MAIN_TRANSTATFLTR.h PERI_NOC_I_PXP_RD_I_MAIN_QOSG.h PERI_NOC_I_PXP_RD_I_MAIN_TRANSTATFLTR.h PERI_NOC_I_PXP_WR_I_MAIN_QOSG.h PERI_NOC_I_PXP_WR_I_MAIN_TRANSTATFLTR.h PERI_NOC_LSTCU.h PERI_NOC_M_E_0_RD_I_M_QOSGEN.h PERI_NOC_M_E_0_RD_I_MAIN_TRANSTATFILT.h PERI_NOC_M_E_0_WR_I_MAIN_QOSGEN.h PERI_NOC_M_E_0_WR_I_MAIN_TRANSTATFILT.h PERI_NOC_M_E_1A_RD_I_MAIN_QOSGEN.h PERI_NOC_M_E_1A_WR_I_MAIN_QOSGEN.h PERI_NOC_M_E_1B_RD_I_MAIN_QOSGEN.h PERI_NOC_M_E_1B_WR_I_MAIN_QOSGEN.h PERI_NOC_M_E_3_RD_I_MAIN_QOSGEN.h PERI_NOC_M_E_3_RD_I_MAIN_TRANSTATFILT.h PERI_NOC_M_E_3_WR_I_MAIN_QOSGEN.h PERI_NOC_M_E_6_RD_I_MAIN_QOSGEN.h PERI_NOC_M_E_6_RD_I_MAIN_TRANSTATFILT.h PERI_NOC_M_E_6_WR_I_MAIN_QOSGEN.h PERI_NOC_M_E_6_WR_I_MAIN_TRANSTATFILT.h PERI_NOC_M_E_7_RD_I_MAIN_QOSGEN.h PERI_NOC_M_E_7_RD_I_MAIN_TRANSTATFILT.h PERI_NOC_M_E_7_WR_I_MAIN_QOSGEN.h PERI_NOC_M_E_7_WR_I_MAIN_TRANSTATFILT.h PERI_NOC_M_E_9_RD_I_MAIN_QOSGEN.h PERI_NOC_M_E_9_WR_I_MAIN_QOSGEN.h PERI_NOC_M_E_9_WR_I_MAIN_TRANSTATFILT.h PERI_NOC_PROBE_LCDIF_RD_MAIN_PROBE.h PERI_NOC_PROBE_LCDIF_RD_MAIN_TRSTPROF.h PERI_NOC_PROBE_M_E_0_MAIN_PROBE.h PERI_NOC_PROBE_M_E_0_MAIN_TRANSTATPROF.h PERI_NOC_PROBE_M_E_3_MAIN_PROBE.h PERI_NOC_PROBE_M_E_3_MAIN_TRANSTATPROF.h PERI_NOC_PROBE_M_E_6_MAIN_PROBE.h PERI_NOC_PROBE_M_E_6_MAIN_TRANSTATPROF.h PERI_NOC_PROBE_M_E_7_MAIN_PROBE.h PERI_NOC_PROBE_M_E_7_MAIN_TRANSTATPROF.h PERI_NOC_PROBE_M_E_9_MAIN_PROBE.h PERI_NOC_PROBE_M_E_9_MAIN_TRANSTATPROF.h PERI_NOC_PROBE_PXP_RD_MAIN_PROBE.h PERI_NOC_PROBE_PXP_RD_MAIN_TRSTPROF.h PERI_NOC_PROBE_PXP_WR_MAIN_PROBE.h PERI_NOC_PROBE_PXP_WR_MAIN_TRSTPROF.h PERI_NOC_TCU.h PERI_NOC_TRDC_MGR.h PERI_NPU_EIM.h PERI_NPU_ERM.h PERI_NPU_LSTCU.h PERI_NPU_TCU.h PERI_OSC24M.h PERI_PCIE_DMA_IATU.h PERI_PCIE_EP.h PERI_PCIE_RC.h PERI_PCIE_SHADOW_EP.h PERI_PDM.h PERI_PLL.h PERI_PWM.h PERI_PXP.h PERI_RGPIO.h PERI_S3MU.h PERI_SEMA42.h PERI_SERDES_SS.h PERI_SINC.h PERI_SRAMCTL.h PERI_SRC_GEN.h PERI_SRC_MEM.h PERI_SRC_XSPR.h PERI_SW_GLOBAL.h PERI_SW_PORT.h PERI_SW_PSEUDO_MAC_PORT.h PERI_SYS_CTR_COMPARE.h PERI_SYS_CTR_CONTROL.h PERI_SYS_CTR_READ.h PERI_TCM_ECC_MCM.h PERI_TMPSNS.h PERI_TMR.h PERI_TMR_GLOBAL.h PERI_TMR_PCI_HDR_TYPE0.h PERI_TPM.h PERI_TRDC_MGR_WKUP1.h PERI_TRDC_MGR_WKUP2.h PERI_TSTMR.h PERI_USB.h PERI_USB3_GLUE.h PERI_USB3_PHY_TCA.h PERI_USBNC.h PERI_WAKEUP_ATU.h PERI_WAKEUP_CMU.h PERI_WAKEUP_DMA_CRC.h PERI_WAKEUP_EIM.h PERI_WAKEUP_ERM.h PERI_WAKEUP_GPT.h PERI_WAKEUP_SAI.h PERI_WAKEUP_TCW.h PERI_WAKEUP_TRDC_MGR_MEGA.h PERI_WAKEUP_USDHC.h PERI_WAKEUP_XSPI_RESPONDER.h PERI_WDOG.h PERI_XBAR1.h PERI_XBAR2.h PERI_XBAR3.h PERI_XCACHE.h PERI_XSPI.h
  group doc
    ../: readme.md
  group drivers
    ../../../../../../../devices/MIMX94398/drivers/cm33/: fsl_cache.c fsl_cache.h
    ../../../../../../../devices/MIMX94398/drivers/: fsl_ccm.c fsl_ccm.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_edma_soc.c fsl_edma_soc.h fsl_cpu.c fsl_cpu.h fsl_elec_spec.h fsl_fract_pll.c fsl_fract_pll.h fsl_fro.c fsl_fro.h fsl_iomuxc.h fsl_irqsteer.c fsl_irqsteer.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.c fsl_lpuart.h fsl_memory.h fsl_msgintr.c fsl_msgintr.h fsl_mu.c fsl_mu.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_rgpio.c fsl_rgpio.h fsl_s3mu.c fsl_s3mu.h fsl_sramctl.c fsl_sramctl.h fsl_src.c fsl_src.h fsl_supply.h fsl_trdc_soc.h
    ../../../../../../../devices/MIMX94398/drivers/edma4/: fsl_edma.c fsl_edma.h fsl_edma_core.h
    ../../../../../../../devices/MIMX94398/drivers/cm33_core1/: fsl_irqsteer_soc.c fsl_irqsteer_soc.h
  group drivers/netc
    ../../../../../../../devices/MIMX94398/drivers/: fsl_netc.h fsl_netc_endpoint.c fsl_netc_endpoint.h fsl_netc_ierb.c fsl_netc_ierb.h fsl_netc_mdio.c fsl_netc_mdio.h fsl_netc_phy_wrapper.c fsl_netc_phy_wrapper.h fsl_netc_soc.c fsl_netc_soc.h fsl_netc_switch.c fsl_netc_switch.h fsl_netc_tag.h fsl_netc_timer.c fsl_netc_timer.h fsl_netc_msg.c fsl_netc_msg.h
  group drivers/netc/netc_hw
    ../../../../../../../devices/MIMX94398/drivers/netc_hw/: fsl_netc_hw.c fsl_netc_hw.h fsl_netc_hw_enetc.c fsl_netc_hw_enetc.h fsl_netc_hw_port.c fsl_netc_hw_port.h fsl_netc_hw_si.c fsl_netc_hw_si.h
  group examples/_boards/imx943evk
    ../../../../../../../examples/_boards/imx943evk/: rsc_table.c rsc_table.h
  group examples/_boards/imx943evk/sm
    ../../../../../../../examples/_boards/imx943evk/sm/: hal_config.h
  group remoteproc/remoteproc
    ../../../../../../../middleware/multicore/remoteproc/: empty_rsc_table.c remoteproc.h
  group freertos/freertos-kernel
    ../../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h freertos_tasks_c_additions.h
  group freertos/freertos-kernel/portable
    ../../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: ReadMe.url heap_4.c
  group freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure
    ../../../../../../../rtos/freertos/freertos-kernel/portable/IAR/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.S port.c portasm.h portasm.s portmacro.h portmacrocommon.h
  group freertos/freertos-kernel/template
    ../../../../../../../rtos/freertos/freertos-kernel/template/: FreeRTOSConfig.h
  group rpmsg-lite/common
    ../../../../../../../middleware/multicore/rpmsg-lite/lib/common/: llist.c
  group rpmsg-lite/include
    ../../../../../../../middleware/multicore/rpmsg-lite/lib/include/: llist.h rpmsg_compiler.h rpmsg_default_config.h rpmsg_env.h rpmsg_lite.h rpmsg_ns.h rpmsg_queue.h virtio_ring.h virtqueue.h
  group rpmsg-lite/include/environment/freertos
    ../../../../../../../middleware/multicore/rpmsg-lite/lib/include/environment/freertos/: rpmsg_env_specific.h
  group rpmsg-lite/include/platform/imx943_m33
    ../../../../../../../middleware/multicore/rpmsg-lite/lib/include/platform/imx943_m33/: rpmsg_platform.h
  group rpmsg-lite/rpmsg_lite
    ../../../../../../../middleware/multicore/rpmsg-lite/lib/rpmsg_lite/: rpmsg_lite.c rpmsg_ns.c rpmsg_queue.c
  group rpmsg-lite/rpmsg_lite/porting/environment
    ../../../../../../../middleware/multicore/rpmsg-lite/lib/rpmsg_lite/porting/environment/: rpmsg_env_freertos.c
  group rpmsg-lite/rpmsg_lite/porting/platform/imx943_m33
    ../../../../../../../middleware/multicore/rpmsg-lite/lib/rpmsg_lite/porting/platform/imx943_m33/: rpmsg_platform.c
  group rpmsg-lite/virtio
    ../../../../../../../middleware/multicore/rpmsg-lite/lib/virtio/: virtqueue.c
  group source
    ../: mcux_config.h netc_txrx_transfer.c FreeRTOSConfig_Gen.h rpmsg_config.h srtm_config.h shell.h shell.c app_srtm.h app_srtm.c
  group srtm/channels
    ../../../../../../../components/srtm/channels/: srtm_rpmsg_endpoint.c srtm_rpmsg_endpoint.h
  group srtm/include
    ../../../../../../../components/srtm/include/: srtm_channel.h srtm_defs.h srtm_dispatcher.h srtm_message.h srtm_peercore.h srtm_service.h
  group srtm/port
    ../../../../../../../components/srtm/port/: srtm_heap_freertos.c srtm_message_pool.c srtm_mutex_freertos.c srtm_sem_freertos.c
  group srtm/services
    ../../../../../../../components/srtm/services/: srtm_audio_service.c srtm_audio_service.h srtm_i2c_service.c srtm_i2c_service.h srtm_netc_service.c srtm_netc_service.h srtm_pdm_edma_adapter.c srtm_pdm_edma_adapter.h srtm_sai_edma_adapter.c srtm_sai_edma_adapter.h
  group srtm/srtm
    ../../../../../../../components/srtm/srtm/: srtm_channel.c srtm_channel_struct.h srtm_dispatcher.c srtm_dispatcher_struct.h srtm_heap.h srtm_list.h srtm_message.c srtm_message_pool.h srtm_message_struct.h srtm_mutex.h srtm_peercore.c srtm_peercore_struct.h srtm_sem.h srtm_service.c srtm_service_struct.h
  group startup/iar
    ../../../../../../../devices/MIMX94398/iar/: startup_MIMX94398_cm33_core1.s
  group utilities
    ../../../../../../../devices/MIMX94398/utilities/debug_console_lite/: fsl_assert.c fsl_assert.h
  group utilities/debug_console_lite
    ../../../../../../../devices/MIMX94398/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h
  group utilities/str
    ../../../../../../../devices/MIMX94398/utilities/str/: fsl_str.c fsl_str.h
  group utilities/shell
    ../../../../../../../devices/MIMX94398/utilities/shell/: fsl_shell.c fsl_shell.h
